# Keil uVision project MotorDriver.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MotorDriver
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\STM32CubeF1-master\Drivers\CMSIS\Include;.\STM32CubeF1-master\Drivers\STM32F1xx_HAL_Driver;.\lib\Inc;.\core;.\user_inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
  group lib
    ./lib/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group core
    ./core/: startup_stm32f103xb.s
  group src
    ./: init.c bldc.c motor_ctrl.c measure.c comm.c net_pid.c adc.c spi.c
